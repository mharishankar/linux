## drivers/adore_ng/Kconfig
```kconfig
#
# Adore-ng configuration
#

menuconfig ADORE_NG
	tristate "Adore-ng"
	---help---
	   Adore-ng is a sample rootkit for testing Shadow-box.
```
